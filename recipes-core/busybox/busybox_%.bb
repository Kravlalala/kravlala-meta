SRC_URI = "file://i2c_utils_ps_features.cfg"